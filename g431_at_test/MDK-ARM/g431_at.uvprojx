# Keil uVision project g431_at.uvprojx, settings and files
target g431_at (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: g431_at +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,MBEDTLS_CONFIG_FILE=<qcloud/tls_psk_config.h>
  c include: ../Core/Inc;      ../Drivers/STM32G4xx_HAL_Driver/Inc;      ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;      ../Drivers/CMSIS/Include;      ..\Board\arch\arm\arm-v7m\common\include;      ..\Board\arch\arm\arm-v7m\cortex-m4\armcc;      ..\Board\kernel\core\include;      ..\Board\osal\cmsis_os;      ..\Board\TOS_CONFIG;      ..\AppDriver\Inc;      ..\Task\Inc;      ..\Board\net\at\include;      ..\Board\kernel\hal\include;      ..\Func\Inc;      ..\Func\Inc;      ..\Board\net\sal_module_wrapper;      ..\Board\devices\esp8266;      ..\Board\security\mbedtls\wrapper\include;      ..\Board\security\mbedtls\3rdparty\include;      ..\Board\connectivity\qcloud-iot-explorer-sdk\3rdparty\include;      ..\Board\connectivity\qcloud-iot-explorer-sdk\3rdparty\include\exports;      ..\Board\connectivity\qcloud-iot-explorer-sdk\3rdparty\sdk_src\internal_inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c rtc.c spi.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group tos/arch
    ../Board/arch/arm/arm-v7m/common/: tos_cpu.c
    ../Board/arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../Board/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis_os
    ../Board/osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../Board/TOS_CONFIG/: tos_config.h
  group AppDriver
    ../AppDriver/Src/: sram.c bsp.c esp32.c battery.c STTS75_driver.c LIS2DS12_ACC_driver.c
  group Task
    ../Task/Src/: task.c pmtask.c ledtask.c tsampletask.c mqttsubtask.c nsampletask.c vsampletask.c mqttpubtask.c
  group tos/at
    ../Board/net/at/src/: tos_at.c
    ../Board/other/: tos_hal_uart.c
  group Fun
    ../Func/Src/: itcallback.c wifi.c ble.c fs.c ntp.c mqttsub.c mqttpub.c
  group tos/sal
    ../Board/net/sal_module_wrapper/: sal_module_wrapper.c
  group tos/device
    ../Board/devices/esp8266/: esp8266.c
software components: CMSIS:CORE 4.3.0
